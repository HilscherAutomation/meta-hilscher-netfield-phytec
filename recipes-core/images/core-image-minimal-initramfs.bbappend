PACKAGE_INSTALL:append = " kernel-module-imx-sdma firmware-imx-sdma-imx7d"
